# Keil uVision project ex2.uvprojx, settings and files
target blink (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ex2
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\st_lib\inc;..\cmsis;..\user;..\driver;..\driver\mpu6050
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group st_lib
    ../st_lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group cmsis
    ../cmsis/: core_cm3.c
  group startup
    ../cmsis/: startup_stm32f10x_md.s
  group user
    ./: main.c stm32f10x_it.c system_stm32f10x.c bsp_motor.c bsp_motor.h bsp_encoder.c bsp_encoder.h bsp_track.c bsp_track.h pid_control.c pid_control.h track_control.c track_control.h turn_control.c turn_control.h task.c task.h bsp_buzzer.c bsp_buzzer.h bsp_led.c bsp_led.h bsp_oled.c bsp_oled.h
  group driver
    ../driver/: usart1.c nvic.c control.c control.h usart1.h
  group mpu6050
    ../driver/mpu6050/: MPU6050.c IOI2C.c inv_mpu.c inv_mpu_dmp_motion_driver.c filter.c
